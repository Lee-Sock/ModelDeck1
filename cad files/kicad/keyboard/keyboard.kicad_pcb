# Repository Lee-Sock/ModelDeck1

## KiCad design cad files/kicad/keyboard/keyboard.kicad_pcb

Board: 2 copper layers, 92 parts (0 on the bottom side), 16 nets.

Parts:
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW42, SW43, SW44, SW45, SW46, SW47, SW48, SW49, SW50, SW51, SW52, SW53, SW54, SW55, SW56, SW57, SW58, SW59, SW60, SW61, SW62, SW63, SW64, SW65, SW66, SW67, SW68, SW69, SW70, SW71, SW72, SW73, SW74, SW75, SW76, SW77, SW78, SW79, SW80, SW81, SW82, SW83, SW84, SW85, SW87, SW88, SW89, SW90, SW92: SW_Push; SW_Hotswap_Kailh_MX_1.00u
SW86, SW91: SW_Push; SW_Hotswap_Kailh_MX_2.00u

Connections:
COL0: SW1.1, SW17.1, SW33.1, SW49.1, SW65.1, SW81.1
COL1: SW2.1, SW18.1, SW34.1, SW50.1, SW66.1, SW82.1
COL2: SW3.1, SW19.1, SW35.1, SW51.1, SW67.1, SW83.1
COL3: SW4.1, SW20.1, SW36.1, SW52.1, SW68.1, SW84.1
COL4: SW5.1, SW21.1, SW37.1, SW53.1, SW69.1, SW85.1
COL5: SW6.1, SW22.1, SW38.1, SW54.1, SW70.1
COL6: SW7.1, SW23.1, SW39.1, SW55.1, SW71.1, SW86.1
COL7: SW8.1, SW24.1, SW40.1, SW56.1, SW72.1, SW87.1
COL8: SW9.1, SW25.1, SW41.1, SW57.1, SW73.1
COL9: SW10.1, SW26.1, SW42.1, SW58.1, SW74.1, SW88.1
COL10: SW11.1, SW27.1, SW43.1, SW59.1, SW75.1, SW89.1
COL11: SW12.1, SW28.1, SW44.1, SW60.1, SW76.1, SW90.1
COL12: SW13.1, SW29.1, SW45.1, SW61.1, SW77.1
COL13: SW14.1, SW30.1, SW46.1, SW62.1, SW78.1, SW91.1
COL14: SW15.1, SW31.1, SW47.1, SW63.1, SW79.1
COL15: SW16.1, SW32.1, SW48.1, SW64.1, SW80.1, SW92.1
